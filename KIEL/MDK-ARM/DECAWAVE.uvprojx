# Keil uVision project DECAWAVE.uvprojx, settings and files
target DECAWAVE (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DECAWAVE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\APP;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../APP/: deca_device.c deca_mutex.c deca_params_init.c deca_range_tables.c deca_spi.c instance.c instance_calib.c instance_common.c instance_fast2wr_a.c instance_fast2wr_c.c instance_fast2wr_t.c main.c port.c stm32f0_discovery.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s
  group LIBRARIES
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
